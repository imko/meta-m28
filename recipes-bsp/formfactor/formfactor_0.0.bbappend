FILESEXTRAPATHS_prepend_m28 := "${THISDIR}/${PN}:"

PRINC = "1"
